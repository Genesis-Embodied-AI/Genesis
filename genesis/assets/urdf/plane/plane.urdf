Commit message: made it work with go1

File: genesis/assets/urdf/plane/plane.urdf (robot description, URDF)
Before this commit: robot plane, 1 links, 0 joints
Links:
- link planeLink: geometry collision box size=200 200 10; visual mesh filename=plane100_light.obj scale=1 1 1
